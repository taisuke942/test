<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP430_BMS_PL536_USB.ewp</path>
  </project>
  <batchBuild/>
</workspace>


