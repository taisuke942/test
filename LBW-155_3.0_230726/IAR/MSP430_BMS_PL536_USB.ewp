# IAR project MSP430_BMS_PL536_USB.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 512
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: SourceCode\; SourceCode\Common\; SourceCode\USB_Common\; SourceCode\USB_CDC_API\; SourceCode\BQ76PL536\; SourceCode\SPI\; SourceCode\UART\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 160
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    SourceCode/: main.c main.h
  group BQ76PL536
    SourceCode/BQ76PL536/: bq_pack.c bq_pack.h data_flash.c data_flash.h
  group Common
    SourceCode/Common/: hal_macros.h hal_pmm.c hal_pmm.h hal_UCS.c hal_UCS.h TLV.c TLV_descriptors.h types.h
  group SPI
    SourceCode/SPI/: spi_if.c spi_if.h TI_IO_Regs.h TI_USCI_SPI_Regs.h
  group UART
    SourceCode/UART/: TI_USCI_UART_Regs.h UART.c UART.h
  group USB
    SourceCode/USB_Common/: defMSP430USB.h descriptors.c descriptors.h dma.c usb.c usb.h usb_eventHandling.c UsbIsr.c UsbIsr.h
    SourceCode/USB_CDC_API/: UsbCdc.c UsbCdc.h
    SourceCode/: USBCDC_constructs.c USBCDC_constructs.h
